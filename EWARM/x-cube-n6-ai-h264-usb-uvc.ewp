# IAR project x-cube-n6-ai-h264-usb-uvc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; VECT_TAB_SRAM; USE_IMX335_SENSOR; USE_VD66GY_SENSOR; USE_VD55G1_SENSOR; USE_VD1943_SENSOR; TX_MAX_PARALLEL_NETWORKS=1; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_FREERTOS; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; APP_HAS_PARALLEL_NETWORKS=0; FEAT_FREERTOS; UVC_LIB_USE_USBX; UX_INCLUDE_USER_DEFINE_FILE; USBL_PACKET_PER_MICRO_FRAME=3; UX_STANDALONE; UVCL_USBX_USE_FREERTOS; UVC_LIB_USE_DMA
  ICCARM.CCIncludePath2: ..\Inc; ..\Model; ..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc; ..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy; ..\STM32Cube_FW_N6\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\STM32Cube_FW_N6\Drivers\CMSIS\Include; ..\STM32Cube_FW_N6\Drivers\CMSIS\DSP\Include; ..\STM32Cube_FW_N6\Drivers\BSP\Components\Common; ..\STM32Cube_FW_N6\Drivers\BSP\STM32N6570-DK; ..\STM32Cube_FW_N6\Utilities\Fonts; ..\STM32Cube_FW_N6\Drivers\BSP\Components\aps256xx; ..\Lib\AI_Runtime\Inc; ..\Lib\AI_Runtime\Npu\ll_aton; ..\Lib\AI_Runtime\Npu\Devices\STM32N6xx; ..\Lib\lib_vision_models_pp\lib_vision_models_pp\Inc; ..\Lib\ai-postprocessing-wrapper; ..\Lib\Camera_Middleware; ..\Lib\Camera_Middleware\sensors; ..\Lib\Camera_Middleware\sensors\imx335; ..\Lib\Camera_Middleware\sensors\vd55g1; ..\Lib\Camera_Middleware\sensors\vd6g; ..\Lib\Camera_Middleware\sensors\vd1943; ..\Lib\Camera_Middleware\ISP_Library\isp\Inc; ..\Lib\Camera_Middleware\ISP_Library\evision\Inc; ..\Lib\FreeRTOS\Source\include; ..\Lib\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure; ..\STM32Cube_FW_N6\Middlewares\ST\VideoEncoder_EWL; ..\STM32Cube_FW_N6\Middlewares\Third_Party\VideoEncoder\inc; ..\STM32Cube_FW_N6\Middlewares\Third_Party\VideoEncoder\source\common; ..\STM32Cube_FW_N6\Middlewares\ST\usbx\common\core\inc; ..\STM32Cube_FW_N6\Middlewares\ST\usbx\ports\generic\inc; ..\STM32Cube_FW_N6\Middlewares\ST\usbx\common\usbx_device_classes\inc; ..\STM32Cube_FW_N6\Middlewares\ST\usbx\common\usbx_stm32_device_controllers; ..\Lib\uvcl\Inc\usbx; ..\Lib\uvcl\Src\usbx; ..\Lib\uvcl\Inc; ..\Lib\uvcl\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: x-cube-n6-ai-h264-usb-uvc.bin
  ILINK.IlinkOutputFile: x-cube-n6-ai-h264-usb-uvc.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\Lib\AI_Runtime\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1100_CM55_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM/Src
    Src/: console.c freertos_libc.c startup_stm32n657xx.s
  group Lib/ai-postprocessing-wrapper
    ../Lib/ai-postprocessing-wrapper/: app_postprocess_fd_blazeface_ui.c app_postprocess_fd_yunet_ui.c app_postprocess_iseg_yolo_v8_ui.c app_postprocess_mpe_pd_uf.c app_postprocess_mpe_yolo_v8_uf.c app_postprocess_mpe_yolo_v8_ui.c app_postprocess_od_blazeface_uf.c app_postprocess_od_blazeface_ui.c app_postprocess_od_blazeface_uu.c app_postprocess_od_st_ssd_uf.c app_postprocess_od_st_yolox_uf.c app_postprocess_od_st_yolox_ui.c app_postprocess_od_yolov2_uf.c app_postprocess_od_yolov2_ui.c app_postprocess_od_yolov5_uu.c app_postprocess_od_yolov8_uf.c app_postprocess_od_yolov8_ui.c app_postprocess_spe_movenet_uf.c app_postprocess_spe_movenet_ui.c app_postprocess_sseg_deeplab_v3_uf.c app_postprocess_sseg_deeplab_v3_ui.c app_postprocess_template.c
  group Lib/AI_Runtime/Npu/Devices/STM32N6xx
    ../Lib/AI_Runtime/Npu/Devices/STM32N6xx/: mcu_cache.c npu_cache.c
  group Lib/AI_Runtime/Npu/ll_aton
    ../Lib/AI_Runtime/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_osal_freertos.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Lib/Camera_Middleware
    ../Lib/Camera_Middleware/: cmw_camera.c cmw_utils.c
  group Lib/Camera_Middleware/ISP_Library/isp/Src
    ../Lib/Camera_Middleware/ISP_Library/isp/Src/: isp_ae_algo.c isp_algo.c isp_awb_algo.c isp_cmd_parser.c isp_core.c isp_services.c isp_tool_com.c
  group Lib/Camera_Middleware/sensors
    ../Lib/Camera_Middleware/sensors/: cmw_imx335.c cmw_vd1943.c cmw_vd55g1.c cmw_vd66gy.c
  group Lib/Camera_Middleware/sensors/imx335
    ../Lib/Camera_Middleware/sensors/imx335/: imx335.c imx335_reg.c
  group Lib/Camera_Middleware/sensors/vd1943
    ../Lib/Camera_Middleware/sensors/vd1943/: vd1943.c
  group Lib/Camera_Middleware/sensors/vd55g1
    ../Lib/Camera_Middleware/sensors/vd55g1/: vd55g1.c
  group Lib/Camera_Middleware/sensors/vd6g
    ../Lib/Camera_Middleware/sensors/vd6g/: vd6g.c
  group Lib/FreeRTOS/Source
    ../Lib/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Lib/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure
    ../Lib/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Lib/FreeRTOS/Source/portable/MemMang
    ../Lib/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Lib/lib_vision_models_pp/lib_vision_models_pp/Src
    ../Lib/lib_vision_models_pp/lib_vision_models_pp/Src/: od_pp_yolov2.c od_pp_yolov5.c od_pp_yolov8.c vision_models_pp.c vision_models_pp_maxi_if32.c vision_models_pp_maxi_is8.c vision_models_pp_maxi_iu8.c
  group Lib/uvcl/Src
    ../Lib/uvcl/Src/: uvcl.c uvcl_desc.c
  group Lib/uvcl/Src/usbx
    ../Lib/uvcl/Src/usbx/: uvcl_usbx.c
  group Model
    ../Model/: network.c stai_network.c
  group Src
    ../Src/: app.c app_cam.c app_enc.c app_fuseprogramming.c draw.c freertos_bsp.c main.c stm32n6xx_it.c utils.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx
    ../STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx/: aps256xx.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g
    ../STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK
    ../STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_xspi.c
  group STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates
    ../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src
    ../STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_tim.c stm32n6xx_hal_uart.c stm32n6xx_hal_xspi.c stm32n6xx_ll_usb.c stm32n6xx_ll_venc.c
  group STM32Cube_FW_N6/Middlewares/ST/usbx/common/core/src
    ../STM32Cube_FW_N6/Middlewares/ST/usbx/common/core/src/: ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_read_run.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_class_dpump_write_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group STM32Cube_FW_N6/Middlewares/ST/usbx/common/usbx_device_classes/src
    ../STM32Cube_FW_N6/Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_video_activate.c ux_device_class_video_change.c ux_device_class_video_control_request.c ux_device_class_video_deactivate.c ux_device_class_video_entry.c ux_device_class_video_initialize.c ux_device_class_video_ioctl.c ux_device_class_video_max_payload_get.c ux_device_class_video_read_payload_free.c ux_device_class_video_read_payload_get.c ux_device_class_video_read_task_function.c ux_device_class_video_read_thread_entry.c ux_device_class_video_reception_start.c ux_device_class_video_stream_get.c ux_device_class_video_tasks_run.c ux_device_class_video_transmission_start.c ux_device_class_video_uninitialize.c ux_device_class_video_write_payload_commit.c ux_device_class_video_write_payload_get.c ux_device_class_video_write_task_function.c ux_device_class_video_write_thread_entry.c
  group STM32Cube_FW_N6/Middlewares/ST/usbx/common/usbx_stm32_device_controllers
    ../STM32Cube_FW_N6/Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group STM32Cube_FW_N6/Middlewares/ST/VideoEncoder_EWL
    ../STM32Cube_FW_N6/Middlewares/ST/VideoEncoder_EWL/: ewl_impl.c
  group STM32Cube_FW_N6/Middlewares/Third_Party/VideoEncoder/source/common
    ../STM32Cube_FW_N6/Middlewares/Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encpreprocess.c encswhwregisters.c
  group STM32Cube_FW_N6/Middlewares/Third_Party/VideoEncoder/source/h264
    ../STM32Cube_FW_N6/Middlewares/Third_Party/VideoEncoder/source/h264/: H264Cabac.c H264CodeFrame.c H264Denoise.c H264EncApi.c H264Init.c H264Mad.c H264NalUnit.c H264PictureBuffer.c H264PictureParameterSet.c H264PutBits.c H264RateControl.c H264Sei.c H264SequenceParameterSet.c H264Slice.c
  group STM32Cube_FW_N6/Middlewares/Third_Party/VideoEncoder/source/jpeg
    ../STM32Cube_FW_N6/Middlewares/Third_Party/VideoEncoder/source/jpeg/: EncJpeg.c EncJpegCodeFrame.c EncJpegInit.c EncJpegPutBits.c JpegEncApi.c
  group STM32Cube_FW_N6/Utilities/lcd
    ../STM32Cube_FW_N6/Utilities/lcd/: stm32_lcd.c
